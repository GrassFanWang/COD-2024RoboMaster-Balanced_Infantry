# Keil uVision project Chassis.uvprojx, settings and files
target Chassis (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Chassis +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1U,ARM_MATH_CHECK
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/API/Inc;../Application/Tasks/Inc;../Bsp/Inc;../Components/Algorithm/Inc;../Components/Controller/Inc;../Components/Device/Inc;../UI/Inc;../Middlewares/ST/ARM/DSP/Inc;..\SystemView\SEGGER\Syscalls;..\SystemView\Sample\FreeRTOSV10;..\SystemView\Config;..\SystemView\Sample\FreeRTOSV10\Patch;..\SystemView\SEGGER
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/API
    ../Application/API/Src/: api_quaternion.c api_trajectory.c
  group Application/Task
    ../Application/Tasks/Src/: CAN_Task.c Control_Task.c Detect_Task.c INS_Task.c
    ../Application/Tasks/Inc/: config.h
  group Components/Device
    ../Components/Device/Src/: bmi088.c minipc.c motor.c referee_info.c remote_control.c
  group BSP
    ../Bsp/Src/: bsp_can.c bsp_gpio.c bsp_dwt.c bsp_mcu.c bsp_spi.c bsp_tick.c bsp_tim.c bsp_uart.c
  group Components/Algorithm
    ../Components/Algorithm/Src/: crc.c kalman.c lpf.c ramp.c Velocity_Fusion.c
  group Components/Controller
    ../Components/Controller/Src/: pid.c
  group UI
    ../UI/Src/: ui_interface.c ui_default_Left_Leg_Group_0.c ui_default_Right_Leg_Group_0.c ui_default_Chassis_Mode_Group_0.c ui_default_SuperCap_Group_1.c ui_default_Mode_Group_0.c ui_default_Text_Group_0.c ui_default_Text_Group_1.c ui_default_Text_Group_2.c ui_default_Supercap_Per_Group_0.c
    ../UI/Inc/: ui.h ui_types.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib arm_cortexM4l_math.lib
